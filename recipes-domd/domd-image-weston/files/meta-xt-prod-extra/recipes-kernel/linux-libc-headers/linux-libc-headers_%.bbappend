RENESAS_BSP_URL = "git://github.com/xen-troops/linux.git"

BRANCH = "s2ram"
SRCREV = "${AUTOREV}"
LINUX_VERSION = "4.14.75"
